# Keil uVision project Example_MSDevice_Blinky.uvproj, settings and files
target Blinky_noOS_M0 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: Blinky_noOS_M0 +hex
  AfterMake: fromelf --cadcombined "$L@L.axf" --output "$Lm0_image_blinky.c"
  c flags: Optim=3 OneElfS=1
  c define: __LPC43XX__ USB_DEVICE_ONLY CORE_M0 EXAMPLE_BLINKY
  c misc: --gnu --c99 --diag_suppress=1207,2776
  c include: ..\..\..\..\libraries\nxpUSBLib\Drivers\USB;..\..\..\..\libraries\BSP;..\..\..\..\libraries\CDL\CMSISv2p00_LPC43xx\inc;..\..\..\..\libraries\CDL\LPC43xxLib\inc;..\common;..\..\..\..\libraries\IPComm
  asm define: NO_CRP
  scatter file: ..\common\lpc43xx_flash.sct
  link misc: --diag_suppress=L6314W,L6329W --datacompressor=off
  group src
    ../common/: main.c ipc_example.c
    ./: Descriptors.c MassStorage.c README_MSCDEV_BLINKY.txt
    ./Lib/: SCSI.c UsbRom.c fatutil.c
    ../Blinky/: Example_Blinky.c
    ./keil_output/: m0_image_blinky.c m0_image_usb.c
  group lib
    ../../../../libraries/CDL/keil_output/: CDL_LPC43xx_M4.lib CDL_LPC43xx_M0.lib
    ../../../../libraries/BSP/keil_output/: BSP_LPC43XX_M4.lib BSP_LPC43XX_M0.lib
    ../../../../libraries/nxpUSBLib/keil_output/: nxpUSBlib_LPC43xx_Device_M4.lib nxpUSBlib_LPC43xx_Device_M0.lib
    ../../../../libraries/IPComm/keil_output/: IPC_noOS_m4.lib IPC_noOS_m0.lib IPC_FreeRTOS_m4.lib IPC_FreeRTOS_m0.lib IPC_uCOSIII_m4.lib IPC_uCOSIII_m0.lib
    ../../../../libraries/FreeRTOS/keil_output/: FreeRTOS_LPC43XX_M4.lib FreeRTOS_LPC43XX_M0.lib
    ../../../../libraries/uCOS/keil_output/: uCOSIII_LPC43XX_M4.lib uCOSIII_LPC43XX_M0.lib
target USB_noOS_M4 (ARM-ADS)
  device: LPC4357 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x1A000000-0x1A07FFFF) IROM2(0x1B000000-0x1B07FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: usbMSDevice_noOS_M4 +hex
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x1A000000)
  c flags: Optim=3 OneElfS=1
  c define: __LPC43XX__ USB_DEVICE_ONLY CORE_M4 EXAMPLE_USB_DEVICE EXAMPLE_BLINKY
  c misc: --gnu --c99 --diag_suppress=1207,2776
  c include: ..\..\..\..\libraries\nxpUSBLib\Drivers\USB;..\..\..\..\libraries\BSP;..\..\..\..\libraries\CDL\CMSISv2p00_LPC43xx\inc;..\..\..\..\libraries\CDL\LPC43xxLib\inc;..\common;..\..\..\..\libraries\IPComm;.\Lib\dosfs
  asm define: NO_CRP
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\common\lpc43xx_flash.sct
  link misc: --diag_suppress=L6314W,L6329W --datacompressor=off
target USB_noOS_M0 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: usbMSDevice_noOS_M0 +hex
  AfterMake: fromelf --cadcombined "$L@L.axf" --output "$Lm0_image_usb.c"
  c flags: Optim=3 OneElfS=1
  c define: __LPC43XX__ USB_DEVICE_ONLY CORE_M0 EXAMPLE_USB_DEVICE EXAMPLE_BLINKY __USE_DOSFS
  c misc: --gnu --c99 --diag_suppress=1207,2776
  c include: as above
  asm define: NO_CRP
  scatter file: ..\common\lpc43xx_flash.sct
  link misc: --diag_suppress=L6314W,L6329W --datacompressor=off
target Blinky_noOS_M4 (ARM-ADS)
  device: LPC4357 NXP (founded by Philips)
  cpu: as above
  output: Blinky_noOS_M4 +hex
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x1A000000)
  c flags: Optim=3 OneElfS=1
  c define: __LPC43XX__ USB_DEVICE_ONLY CORE_M4 EXAMPLE_BLINKY
  c misc: --gnu --c99 --diag_suppress=1207,2776
  c include: as above
  asm define: NO_CRP
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\common\lpc43xx_flash.sct
  link misc: --diag_suppress=L6314W,L6329W --datacompressor=off
target Blinky_FreeRTOS_M0 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: Blinky_FreeRTOS_M0 +hex
  AfterMake: as above
  c flags: Optim=3 OneElfS=1
  c define: __LPC43XX__ USB_DEVICE_ONLY CORE_M0 EXAMPLE_BLINKY
  c misc: --gnu --c99 --diag_suppress=1207,2776
  c include: ..\..\..\..\libraries\nxpUSBLib\Drivers\USB;..\..\..\..\libraries\BSP;..\..\..\..\libraries\CDL\CMSISv2p00_LPC43xx\inc;..\..\..\..\libraries\CDL\LPC43xxLib\inc;..\common;..\..\..\..\libraries\IPComm;..\..\..\..\libraries\FreeRTOS\config;..\..\..\..\libraries\FreeRTOS\Source\include;..\..\..\..\libraries\FreeRTOS\Source\portable\RVDS\ARM_CM0
  asm define: NO_CRP
  scatter file: ..\common\lpc43xx_flash.sct
  link misc: --diag_suppress=L6314W,L6329W --datacompressor=off
target USB_FreeRTOS_M4 (ARM-ADS)
  device: LPC4357 NXP (founded by Philips)
  cpu: as above
  output: usbMSDevice_FreeRTOS_M4 +hex
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x1A000000)
  c flags: Optim=3 OneElfS=1
  c define: __LPC43XX__ USB_DEVICE_ONLY CORE_M4 EXAMPLE_USB_DEVICE EXAMPLE_BLINKY OS_FREE_RTOS
  c misc: --gnu --c99 --diag_suppress=1207,2776
  c include: ..\..\..\..\libraries\nxpUSBLib\Drivers\USB;..\..\..\..\libraries\BSP;..\..\..\..\libraries\CDL\CMSISv2p00_LPC43xx\inc;..\..\..\..\libraries\CDL\LPC43xxLib\inc;..\common;..\..\..\..\libraries\IPComm;.\Lib\dosfs;..\..\..\..\libraries\FreeRTOS\config;..\..\..\..\libraries\FreeRTOS\Source\include;..\..\..\..\libraries\FreeRTOS\Source\portable\RVDS\ARM_CM4F
  asm define: NO_CRP
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\common\lpc43xx_flash.sct
  link misc: --diag_suppress=L6314W,L6329W --datacompressor=off
target USB_FreeRTOS_M0 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: usbMSDevice_FreeRTOS_M0 +hex
  AfterMake: fromelf --cadcombined "$L@L.axf" --output "$Lm0_image_usb.c"
  c flags: Optim=3 OneElfS=1
  c define: __LPC43XX__ USB_DEVICE_ONLY CORE_M0 EXAMPLE_USB_DEVICE EXAMPLE_BLINKY __USE_DOSFS OS_FREE_RTOS
  c misc: --gnu --c99 --diag_suppress=1207,2776
  c include: ..\..\..\..\libraries\nxpUSBLib\Drivers\USB;..\..\..\..\libraries\BSP;..\..\..\..\libraries\CDL\CMSISv2p00_LPC43xx\inc;..\..\..\..\libraries\CDL\LPC43xxLib\inc;..\common;..\..\..\..\libraries\IPComm;.\Lib\dosfs;..\..\..\..\libraries\FreeRTOS\config;..\..\..\..\libraries\FreeRTOS\Source\include;..\..\..\..\libraries\FreeRTOS\Source\portable\RVDS\ARM_CM0
  asm define: NO_CRP
  scatter file: ..\common\lpc43xx_flash.sct
  link misc: --diag_suppress=L6314W,L6329W --datacompressor=off
target Blinky_FreeRTOS_M4 (ARM-ADS)
  device: LPC4357 NXP (founded by Philips)
  cpu: as above
  output: Blinky_FreeRTOS_M4 +hex
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x1A000000)
  c flags: Optim=3 OneElfS=1
  c define: __LPC43XX__ USB_DEVICE_ONLY CORE_M4 EXAMPLE_BLINKY OS_FREE_RTOS
  c misc: --gnu --c99 --diag_suppress=1207,2776
  c include: ..\..\..\..\libraries\nxpUSBLib\Drivers\USB;..\..\..\..\libraries\BSP;..\..\..\..\libraries\CDL\CMSISv2p00_LPC43xx\inc;..\..\..\..\libraries\CDL\LPC43xxLib\inc;..\common;..\..\..\..\libraries\IPComm;..\..\..\..\libraries\FreeRTOS\config;..\..\..\..\libraries\FreeRTOS\Source\include;..\..\..\..\libraries\FreeRTOS\Source\portable\RVDS\ARM_CM4F
  asm define: NO_CRP
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\common\lpc43xx_flash.sct
  link misc: --diag_suppress=L6314W,L6329W --datacompressor=off
