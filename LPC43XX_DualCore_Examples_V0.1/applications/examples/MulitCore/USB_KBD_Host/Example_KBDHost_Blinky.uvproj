# Keil uVision project Example_KBDHost_Blinky.uvproj, settings and files
target Blinky_noOS_M0 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: Blinky_noOS_M0
  AfterMake: fromelf --cadcombined "$L@L.axf" --output "$Lm0_image_blinky.c"
  c flags: Optim=3 OneElfS=1
  c define: __LPC43XX__ USB_HOST_ONLY CORE_M0 EXAMPLE_BLINKY EXAMPLE_USB_HOST
  c misc: --gnu --c99 --diag_suppress=1207,2776
  c include: ..\..\..\..\libraries\nxpUSBLib\Drivers\USB;..\..\..\..\libraries\BSP;..\..\..\..\libraries\nxpUSBLib\Drivers\USB\Class\Common;..\..\..\..\libraries\IPComm;..\..\..\..\libraries\CDL\CMSISv2p00_LPC43xx\inc;..\..\..\..\libraries\CDL\LPC43xxLib\inc;..\common
  scatter file: ..\common\lpc43xx_flash.sct
  group src
    ../common/: main.c ipc_example.c
    ../Blinky/: Example_Blinky.c
    ./: KeyboardHost.c keyboardIPC.c README_KBDHOST_BLINKY.txt
    ./keil_output/: m0_image_usb.c m0_image_blinky.c
  group lib
    ../../../../libraries/CDL/keil_output/: CDL_LPC43xx_M0.lib CDL_LPC43xx_M4.lib
    ../../../../libraries/BSP/keil_output/: BSP_LPC43XX_M0.lib BSP_LPC43XX_M4.lib
    ../../../../libraries/nxpUSBLib/keil_output/: nxpUSBlib_LPC43xx_Host_M0.lib nxpUSBlib_LPC43xx_Host_M4.lib
    ../../../../libraries/IPComm/keil_output/: IPC_noOS_m0.lib IPC_noOS_m4.lib IPC_FreeRTOS_m0.lib IPC_FreeRTOS_m4.lib IPC_uCOSIII_m0.lib IPC_uCOSIII_m4.lib
    ../../../../libraries/FreeRTOS/keil_output/: FreeRTOS_LPC43XX_M0.lib FreeRTOS_LPC43XX_M4.lib
    ../../../../libraries/uCOS/keil_output/: uCOSIII_LPC43XX_M0.lib uCOSIII_LPC43XX_M4.lib
target USB_noOS_M4 (ARM-ADS)
  device: LPC4357 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x1A000000-0x1A07FFFF) IROM2(0x1B000000-0x1B07FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: usbKBDHost_noOS_M4
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x1A000000)
  c flags: Optim=3 OneElfS=1
  c define: __LPC43XX__ USB_HOST_ONLY CORE_M4 EXAMPLE_USB_HOST EXAMPLE_BLINKY
  c misc: --gnu --c99 --diag_suppress=1207,2776
  c include: ..\common;..\..\..\..\libraries\nxpUSBLib\Drivers\USB;..\..\..\..\libraries\BSP;..\..\..\..\libraries\CDL\CMSISv2p00_LPC43xx\inc;..\..\..\..\libraries\CDL\LPC43xxLib\inc;..\..\..\..\libraries\IPComm
  asm define: NO_CRP
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\common\lpc43xx_flash.sct
target USB_noOS_M0 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: usbKBDHost_noOS_M0
  AfterMake: fromelf --cadcombined "$L@L.axf" --output "$Lm0_image_usb.c"
  c flags: Optim=3 OneElfS=1
  c define: __LPC43XX__ USB_HOST_ONLY CORE_M0 EXAMPLE_USB_HOST EXAMPLE_BLINKY
  c misc: --gnu --c99 --diag_suppress=1207,2776
  c include: ..\..\..\..\libraries\nxpUSBLib\Drivers\USB;..\..\..\..\libraries\BSP;..\..\..\..\libraries\nxpUSBLib\Drivers\USB\Class\Common;..\..\..\..\libraries\CDL\CMSISv2p00_LPC43xx\inc;..\..\..\..\libraries\CDL\LPC43xxLib\inc;..\..\..\..\libraries\IPComm;..\common
  scatter file: ..\common\lpc43xx_flash.sct
target Blinky_noOS_M4 (ARM-ADS)
  device: LPC4357 NXP (founded by Philips)
  cpu: as above
  output: Blinky_noOS_M4
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x1A000000)
  c flags: Optim=3 OneElfS=1
  c define: __LPC43XX__ USB_HOST_ONLY CORE_M4 EXAMPLE_BLINKY EXAMPLE_USB_HOST
  c misc: --gnu --c99 --diag_suppress=1207,2776
  c include: ..\..\..\..\libraries\nxpUSBLib\Drivers\USB;..\..\..\..\libraries\BSP;..\..\..\..\libraries\CDL\CMSISv2p00_LPC43xx\inc;..\..\..\..\libraries\CDL\LPC43xxLib\inc;..\..\..\..\libraries\IPComm;..\common
  asm define: NO_CRP
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\common\lpc43xx_flash.sct
target Blinky_FreeRTOS_M0 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: Blinky_FreeRTOS_M0
  AfterMake: as above
  c flags: Optim=3 OneElfS=1
  c define: __LPC43XX__ USB_HOST_ONLY CORE_M0 EXAMPLE_USB_HOST EXAMPLE_BLINKY OS_FREE_RTOS
  c misc: --gnu --c99 --diag_suppress=1207,2776
  c include: ..\common;..\..\..\..\libraries\nxpUSBLib\Drivers\USB;..\..\..\..\libraries\BSP;..\..\..\..\libraries\CDL\CMSISv2p00_LPC43xx\inc;..\..\..\..\libraries\CDL\LPC43xxLib\inc;..\..\..\..\libraries\IPComm;..\..\..\..\libraries\FreeRTOS\config;..\..\..\..\libraries\FreeRTOS\Source\include;..\..\..\..\libraries\FreeRTOS\Source\portable\RVDS\ARM_CM4F
  asm define: NO_CRP
  scatter file: ..\common\lpc43xx_flash.sct
target USB_FreeRTOS_M4 (ARM-ADS)
  device: LPC4357 NXP (founded by Philips)
  cpu: as above
  output: usbKBDHost_FreeRTOS_M4
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x1A000000)
  c flags: Optim=3 OneElfS=1
  c define: __LPC43XX__ USB_HOST_ONLY CORE_M4 EXAMPLE_USB_HOST EXAMPLE_BLINKY OS_FREE_RTOS
  c misc: --gnu --c99 --diag_suppress=1207,2776
  c include: as above
  asm define: NO_CRP
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\common\lpc43xx_flash.sct
target USB_FreeRTOS_M0 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: usbKBDHost_FreeRTOS_M0
  AfterMake: fromelf --cadcombined "$L@L.axf" --output "$Lm0_image_usb.c"
  c flags: Optim=3
  c define: as above
  c misc: --gnu --c99 --diag_suppress=1207,2776
  c include: as above
  asm define: NO_CRP
  scatter file: ..\common\lpc43xx_flash.sct
target Blinky_FreeRTOS_M4 (ARM-ADS)
  device: LPC4350 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1001FFFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: Blinky_FreeRTOS_M4
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x1A000000)
  c flags: Optim=3 OneElfS=1
  c define: as above
  c misc: --gnu --c99 --diag_suppress=1207,2776
  c include: as above
  asm define: NO_CRP
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\common\lpc43xx_flash.sct
