# Keil uVision project LPC43XX_FreeRTOS.uvproj, settings and files
target LPC43XX_M4 (ARM-ADS)
  device: LPC4350 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1001FFFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: FreeRTOS_LPC43XX_M4 (library)
  c flags: Optim=3 OneElfS=1
  c define: __LPC43XX__ CORE_M4
  c include: .\Source\include;.\Source\portable\RVDS\ARM_CM4F;.\config;..\CDL\LPC43xxLib\inc
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group source
    ./Source/: list.c queue.c tasks.c timers.c
    ./Source/portable/MemMang/: heap_3.c
    ./Source/portable/RVDS/ARM_CM4F/: port_m4.c
    ./Source/portable/RVDS/ARM_CM0/: port_m0.c
  group misc
    ./config/: lpc43xx_m0_TickConfig.c
    ./: freeRTOS_hooks.c
target LPC43XX_M0 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: FreeRTOS_LPC43XX_M0 (library)
  c flags: Optim=3 OneElfS=1
  c define: __LPC43XX__ CORE_M0
  c include: .\Source\include;.\Source\portable\RVDS\ARM_CM0;.\config;..\CDL\LPC43xxLib\inc
  asm define: NO_CRP
