# Keil uVision project LPC43XX_CDL.uvproj, settings and files
target LPC43xx_M4 (ARM-ADS)
  device: LPC4350 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1001FFFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: CDL_LPC43xx_M4 (library)
  c flags: Optim=3 OneElfS=1
  c define: __LPC43XX__ CORE_M4
  c include: .\CMSISv2p00_LPC43xx\inc;.\LPC43xxLib\inc
  asm define: NO_CRP
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Core
    ./CMSISv2p00_LPC17xx/src/: core_cm3.c
    ./CMSISv2p00_LPC11Uxx/src/: core_cm0.c
    ./CMSISv2p00_LPC43xx/src/: core_cm4.c
  group LPC43xx
    ./LPC43xxLib/src/: lpc43xx_adc.c lpc43xx_atimer.c lpc43xx_can.c lpc43xx_cgu.c lpc43xx_dac.c lpc43xx_emc.c lpc43xx_evrt.c lpc43xx_gpdma.c lpc43xx_gpio.c lpc43xx_i2c.c lpc43xx_i2s.c lpc43xx_mcpwm.c lpc43xx_nvic.c lpc43xx_pwr.c lpc43xx_qei.c lpc43xx_rgu.c lpc43xx_rit.c lpc43xx_rtc.c lpc43xx_sct.c lpc43xx_scu.c lpc43xx_ssp.c lpc43xx_timer.c lpc43xx_uart.c lpc43xx_wwdt.c sdio.c
    ./CMSISv2p00_LPC43xx/src/: fpu_enable.c fpu_init.c system_LPC43xx.c startup_LPC43xx.s startup_LPC43xx_M0.s
    ./LPC43xxLib/lib/: spifi_drv_M4.lib
target LPC43xx_M0 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: CDL_LPC43xx_M0 (library)
  c flags: Optim=3 OneElfS=1
  c define: __LPC43XX__ CORE_M0
  c include: .\CMSISv2p00_LPC43xx\inc;.\LPC43xxLib\inc
  asm define: NO_CRP
