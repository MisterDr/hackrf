# Keil uVision project LPC43XX_nxpUSBlib.uvproj, settings and files
target LPC43xx_Host_M4 (ARM-ADS)
  device: LPC4350 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1001FFFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: nxpUSBlib_LPC43xx_Host_M4 (library)
  c flags: Optim=3 OneElfS=1
  c define: __LPC43XX__ USB_HOST_ONLY CORE_M4 BSP_HAS_DELAY
  c misc: --gnu --c99 --diag_suppress=1207
  c include: ..\CDL\CMSISv2p00_LPC43xx\inc;..\CDL\LPC43xxLib\inc
  asm define: NO_CRP
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Class
    ./Drivers/USB/Class/Common/: HIDParser.c
    ./Drivers/USB/Class/Device/: AudioClassDevice.c CDCClassDevice.c HIDClassDevice.c MassStorageClassDevice.c MIDIClassDevice.c RNDISClassDevice.c
    ./Drivers/USB/Class/Host/: AudioClassHost.c CDCClassHost.c HIDClassHost.c MassStorageClassHost.c MIDIClassHost.c PrinterClassHost.c RNDISClassHost.c StillImageClassHost.c
  group Core
    ./Drivers/USB/Core/: ConfigDescriptor.c DeviceStandardReq.c Events.c HostStandardReq.c USBTask.c USBMemory.c
  group LPC
    ./Drivers/USB/Core/LPC/: Device_LPC.c Endpoint_LPC.c EndpointStream_LPC.c Host_LPC.c Pipe_LPC.c PipeStream_LPC.c USBController_LPC.c
  group HAL
    ./Drivers/USB/Core/LPC/HAL/LPC18XX/: HAL_LPC18xx.c
    ./Drivers/USB/Core/LPC/HAL/LPC17XX/: HAL_LPC17xx.c
    ./Drivers/USB/Core/LPC/HAL/LPC11UXX/: HAL_LPC11Uxx.c
  group HCD
    ./Drivers/USB/Core/LPC/HCD/: HCD.c
    ./Drivers/USB/Core/LPC/HCD/OHCI/: OHCI.c
    ./Drivers/USB/Core/LPC/HCD/EHCI/: EHCI.c
  group DCD
    ./Drivers/USB/Core/LPC/DCD/LPC11UXX/: Endpoint_LPC11Uxx.c
    ./Drivers/USB/Core/LPC/DCD/LPC17XX/: Endpoint_LPC17xx.c
    ./Drivers/USB/Core/LPC/DCD/LPC18XX/: Endpoint_LPC18xx.c
    ./Drivers/USB/Core/LPC/DCD/LPC18XX/USBRom/: usbd_hid.c usbd_msc.c usbd_rom.c usbd_cdc.c
  group Config
    ./: nxpUSBlibConfig.h
target LPC43xx_Device_M4 (ARM-ADS)
  device: LPC4350 NXP (founded by Philips)
  cpu: as above
  output: nxpUSBlib_LPC43xx_Device_M4 (library)
  c flags: Optim=3 OneElfS=1
  c define: __LPC43XX__ USB_DEVICE_ONLY CORE_M4 BSP_HAS_DELAY
  c misc: --gnu --c99 --diag_suppress=1207
  c include: ..\CDL\CMSISv2p00_LPC43xx\inc;..\CDL\LPC43xxLib\inc
  asm define: NO_CRP
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
target LPC43xx_Host_M0 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: nxpUSBlib_LPC43xx_Host_M0 (library)
  c flags: Optim=3 OneElfS=1
  c define: __LPC43XX__ USB_HOST_ONLY CORE_M0 USB0_IRQHandler=M0_USB0_IRQHandler USB1_IRQHandler=M0_USB1_IRQHandler BSP_HAS_DELAY
  c misc: --gnu --c99 --diag_suppress=1207
  c include: ..\CDL\CMSISv2p00_LPC43xx\inc;..\CDL\LPC43xxLib\inc
  asm define: NO_CRP
target LPC43xx_Device_M0 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: nxpUSBlib_LPC43xx_Device_M0 (library)
  c flags: Optim=3 OneElfS=1
  c define: __LPC43XX__ USB_DEVICE_ONLY CORE_M0 USB0_IRQHandler=M0_USB0_IRQHandler USB1_IRQHandler=M0_USB1_IRQHandler BSP_HAS_DELAY
  c misc: --gnu --c99 --diag_suppress=1207
  c include: ..\CDL\CMSISv2p00_LPC43xx\inc;..\CDL\LPC43xxLib\inc
  asm define: NO_CRP
