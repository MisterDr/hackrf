# Keil uVision project LPC43XX_BSP.uvproj, settings and files
target MCB4300_M4 (ARM-ADS)
  device: LPC4350 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1001FFFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: BSP_LPC43XX_M4 (library)
  c flags: Optim=3 OneElfS=1
  c define: __LPC43XX__ BOARD=BOARD_MCB1800_4300 CORE_M4 USED_UART_DEBUG_PORT=3
  c include: ..\CDL\CMSISv2p00_LPC43xx\inc;..\CDL\LPC43xxLib\inc;..\lwip\lwip\src\include\ipv4;..\lwip\lwip\src\include;..\lwip\lwiplpc;..\lwip\lwiplpc\configs;..\emWin\emWin_header;..\emWin\emWin_Config;.\
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group common
    ./MCB1800_4300/: bsp_MCB1800_4300.c lcd_MCB1800_4300.c tsc_MCB1800_4300.c
    ./HITEX/: bsp_HITEX.c
    ./: DataRam.c bsp.c
    ../CDL/LPC43xxLib/src/: debug_frmwrk.c
target MCB4300_M0 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: BSP_LPC43XX_M0 (library)
  c flags: Optim=3 OneElfS=1
  c define: BOARD=BOARD_MCB1800_4300 __LPC43XX__  CORE_M0 USED_UART_DEBUG_PORT=3
  c include: as above
