# Keil uVision project LPC43XX_IPC_m4m0.uvproj, settings and files
target Standalone_M4 (ARM-ADS)
  device: LPC4350 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1001FFFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: IPC_noOS_m4 (library)
  c flags: Optim=3 OneElfS=1
  c define: __LPC43XX__ CORE_M4 EVENT_ON_RX
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group source
    ./: ipc_msg.c
target Standalone_M0 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: IPC_noOS_m0 (library)
  c flags: Optim=3 OneElfS=1
  c define: __LPC43XX__ CORE_M0 EVENT_ON_RX
target FreeRTOS_M4 (ARM-ADS)
  device: LPC4350 NXP (founded by Philips)
  cpu: as above
  output: IPC_FreeRTOS_m4 (library)
  c flags: Optim=3 OneElfS=1
  c define: __LPC43XX__ CORE_M4 EVENT_ON_RX OS_FREE_RTOS
  c include: ..\FreeRTOS\Source\include;..\FreeRTOS\config;..\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\CDL\LPC43xxLib\inc
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
target FreeRTOS_M0 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: IPC_FreeRTOS_m0 (library)
  c flags: Optim=3 OneElfS=1
  c define: __LPC43XX__ CORE_M0 EVENT_ON_RX OS_FREE_RTOS
  c include: as above
