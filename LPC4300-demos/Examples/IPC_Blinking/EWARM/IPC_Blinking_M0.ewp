# IAR project IPC_Blinking_M0.ewp, settings and files
configuration LPC43xx_IntSRAM (ARM, debug)
  General.OGChipSelectEditMenu: LPC4350_M0 NXP LPC4350_M0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M0
  ICCARM.CCDiagSuppress: Pa050, Pe161
  ICCARM.CCIncludePath2: ..; ..\..\..\Core\CMSIS\Include; ..\..\..\Core\Device\NXP\lpc43xx\Include; ..\..\..\Drivers\include; ..\..\..\Boards
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: IPC_Blinking_M0.bin
  postbuild: ..\bin2array.exe "$TARGET_BPATH$.bin" "..\CM0_image.h"
  ILINK.IlinkOutputFile: IPC_Blinking_M0.out
  ILINK.IlinkIcfFile: ..\..\..\Linker\EWARM\lpc_4350_db1_m0_iram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: ipc_protocol.h main_m0.c
  group Drivers
    ../../../Drivers/source/: lpc43xx_gpio.c lpc43xx_scu.c
  group Startup
    ../../../Core/Device/NXP/LPC43xx/Source/Templates/IAR/: startup_LPC43xx_M0.s
