# IAR project FreeRTOS.ewp, settings and files
configuration LPC4350_IntSRAM (ARM, debug)
  General.OGChipSelectEditMenu: LPC4350_M4 NXP LPC4350_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M4
  ICCARM.CCDiagSuppress: Pa050, Pa092, Pe021, Pe161, Pe550, Pa082, Pa039
  ICCARM.CCIncludePath2: ..; ..\..\..\Core\CMSIS\Include; ..\..\..\Core\Device\NXP\lpc43xx\Include; ..\..\..\Drivers\include; ..\..\..\Boards; ..\FreeRTOS\include; ..\FreeRTOS\portable\IAR\ARM_CM4F
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..
  OBJCOPY.OOCOutputFile: FreeRTOS.srec
  ILINK.IlinkOutputFile: FreeRTOS.out
  ILINK.IlinkIcfFile: ..\..\..\Linker\EWARM\lpc_4350_db1_m4_iram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration LPC4350_ExtFLASH (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ..\..\..\Linker\EWARM\lpc_4350_db1_m4_extflash_lcd.icf
configuration LPC4357_ExtFLASH (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4357_M4 NXP LPC4357_M4
  ILINK.IlinkIcfFile: ..\..\..\Linker\EWARM\lpc_4357_db1_m4_extflash.icf
configuration LPC4357_IntFLASH (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4357_M4 NXP LPC4357_M4
  group (top)
    ../: easyweb_task.c led_task.c main.c usb_task.c
  group CMSIS-CM4
    ../../../Core/Device/NXP/LPC43xx/Source/Templates/: system_LPC43xx.c
  group Drivers
    ../../../Boards/: lpc4350_db1_emc.c
    ../../../Drivers/source/: lpc43xx_cgu.c lpc43xx_gpio.c lpc43xx_rgu.c lpc43xx_scu.c
  group Easyweb
    ../easyweb/: emac.c tcpip.c
  group FreeRTOS
    ../FreeRTOS/portable/MemMang/: heap_2.c
    ../FreeRTOS/: list.c queue.c tasks.c timers.c
    ../FreeRTOS/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Startup
    ../../../Core/Device/NXP/LPC43xx/Source/Templates/IAR/: startup_LPC43xx.s
