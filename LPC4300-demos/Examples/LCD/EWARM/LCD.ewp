# IAR project LCD.ewp, settings and files
configuration LPC4350_IntSRAM (ARM, debug)
  General.OGChipSelectEditMenu: LPC4350_M4 NXP LPC4350_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M4
  ICCARM.CCDiagSuppress: Pa050, Pe161, Pa092
  ICCARM.CCIncludePath2: ..; ..\..\..\Core\CMSIS\Include; ..\..\..\Core\Device\NXP\lpc43xx\Include; ..\..\..\Drivers\include; ..\..\..\Boards
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LCD.srec
  ILINK.IlinkOutputFile: LCD.out
  ILINK.IlinkIcfFile: ..\..\..\Linker\EWARM\lpc_4350_db1_m4_iram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration LPC4350_ExtFLASH (ARM, debug)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: LCD.hex
  ILINK.IlinkIcfFile: ..\..\..\Linker\EWARM\lpc_4350_db1_m4_extflash_lcd.icf
  ILINK.IlinkExtraOptions: --image_input ..\title_rgb565.bin,TITLE_IMAGE,.image0,4; --image_input ..\diolan_rgb565.bin,DIOLAN_IMAGE,.image1,4; --image_input ..\arrow_rgb565.bin,ARROW_IMAGE,.image2,4; --keep TITLE_IMAGE; --keep DIOLAN_IMAGE; --keep ARROW_IMAGE
configuration LPC4357_IntSRAM (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4357_M4 NXP LPC4357_M4
  ILINK.IlinkIcfFile: ..\..\..\Linker\EWARM\lpc_4357_db1_m4_iram.icf
configuration LPC4357_ExtFLASH (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4357_M4 NXP LPC4357_M4
  OBJCOPY.OOCOutputFile: LCD.hex
  ILINK.IlinkIcfFile: ..\..\..\Linker\EWARM\lpc_4357_db1_m4_extflash_lcd.icf
  ILINK.IlinkExtraOptions: as above
configuration LPC4357_IntFLASH (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4357_M4 NXP LPC4357_M4
  group (top)
    ../: ltv350qv.c main.c tsc2007.c
  group CMSIS_CM4
    ../../../Core/Device/NXP/LPC43xx/Source/Templates/: system_LPC43xx.c
  group Drivers
    ../../../Boards/: lpc4350_db1_emc.c
    ../../../Drivers/source/: lpc43xx_cgu.c lpc43xx_gpio.c lpc43xx_i2c.c lpc43xx_lcd.c lpc43xx_scu.c lpc43xx_ssp.c
  group Startup
    ../../../Core/Device/NXP/LPC43xx/Source/Templates/IAR/: startup_LPC43xx.s
