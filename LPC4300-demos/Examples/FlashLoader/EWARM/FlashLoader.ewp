# IAR project FlashLoader.ewp, settings and files
configuration Internal SRAM (ARM, debug)
  General.OGChipSelectEditMenu: LPC4350_M4 NXP LPC4350_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..; framework2
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FlashLoader.bin
  ILINK.IlinkOutputFile: FlashLoader.out
  ILINK.IlinkIcfFile: lpc_4350_db1_flashloader.icf
  ILINK.IlinkProgramEntryLabel: FlashInitEntry
  group (top)
    ../: flash_DiolanLPC4350DB1.c
  group Framework
    framework2/: flash_loader.c flash_loader_asm.s
