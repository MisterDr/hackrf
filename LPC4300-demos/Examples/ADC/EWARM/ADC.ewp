# IAR project ADC.ewp, settings and files
configuration LPC4350_IntSRAM (ARM, debug)
  General.OGChipSelectEditMenu: LPC4350_M4 NXP LPC4350_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M4
  ICCARM.CCDiagSuppress: Pa050, Pe161
  ICCARM.CCIncludePath2: ..; ..\..\..\Core\CMSIS\Include; ..\..\..\Core\Device\NXP\lpc43xx\Include; ..\..\..\Drivers\include; ..\..\..\Boards
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ADC.srec
  ILINK.IlinkOutputFile: ADC.out
  ILINK.IlinkIcfFile: ..\..\..\Linker\EWARM\lpc_4350_db1_m4_iram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration LPC4350_ExtFLASH (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ..\..\..\Linker\EWARM\lpc_4350_db1_m4_extflash_lcd.icf
configuration LPC4357_IntSRAM (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4357_M4 NXP LPC4357_M4
  ILINK.IlinkIcfFile: ..\..\..\Linker\EWARM\lpc_4357_db1_m4_iram.icf
configuration LPC4357_ExtFLASH (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4357_M4 NXP LPC4357_M4
  ILINK.IlinkIcfFile: ..\..\..\Linker\EWARM\lpc_4357_db1_m4_extflash.icf
configuration LPC4357_IntFLASH (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4357_M4 NXP LPC4357_M4
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\NXP\LPC4357_M4.icf
  group (top)
    ../: main.c
  group CMSIS-CM4
    ../../../Core/Device/NXP/LPC43xx/Source/Templates/: system_LPC43xx.c
  group Drivers
    ../../../Drivers/source/: lpc43xx_adc.c lpc43xx_cgu.c lpc43xx_scu.c
  group Startup
    ../../../Core/Device/NXP/LPC43xx/Source/Templates/IAR/: startup_LPC43xx.s
